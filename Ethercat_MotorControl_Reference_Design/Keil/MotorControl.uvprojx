# Keil uVision project MotorControl.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: AX58200_MotorControl
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: .\genImages.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M480\Include;..\Library\StdDriver\inc;..\Source;..\For_SSC_Tool\Src;..\Source\CiA402;..\Source\McInterface;..\Source\Mchal;..\Source\McStack;..\Source\Debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_M480.s
    ../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group User
    ../Source/: main.c
  group Library
    ../Library/StdDriver/src/: acmp.c asix_retarget.c bpwm.c can.c ccap.c clk.c crc.c crypto.c dac.c eadc.c ebi.c ecap.c epwm.c fmc.c gpio.c hsusbd.c i2c.c i2s.c pdma.c qei.c qspi.c rtc.c sc.c scuart.c sdh.c spi.c spim.c sys.c timer.c timer_pwm.c trng.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group CiA402
    ../Source/CiA402/: cia402.c cia402csp.c cia402hm.c cia402pp.c
  group Beckhoff SSC
    ../For_SSC_Tool/Src/: AX58200_FoeAppl.c AX58200_MotorControl.c AX58200_Hw.c bootmode.c coeappl.c ecatappl.c ecatcoe.c ecatfoe.c ecatslv.c foeappl.c mailbox.c objdef.c sdoserv.c AX58200_MotorControlObjects.h
  group McInterface
    ../Source/McInterface/: mc.c mc_it.c mc_math.c mc_cfg.h mc_types.h
  group McStack
    ../Source/McStack/: bus_vol_sensor.c curr_fdbk.c das.c flash.c incremental_fdbk.c loop_control.c pid.c servo_commu.c stepper_mode.c svpwm.c sw_protection.c temp_sensor.c trajectory_ctrl.c param_def.h
  group McHal
    ../Source/Mchal/: McHal_eadc.c McHal_epwm.c McHal_gpio.c McHal_husb.c McHal_qei.c McHal_tim.c McHal_misc.c McHal_vcp_desc.c
  group Debug
    ../Source/Debug/: ax_uart.c clicmd.c console.c printd.c test.c
software components: CMSIS:CORE 5.1.2
