# IAR project MotorControl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\Library\CMSIS\Include; ..\..\..\Library\StdDriver\inc; ..\Source; ..\For_SSC_Tool\Src; ..\Source\McStack; ..\Source\McInterface; ..\Source\Mchal; ..\Source\CiA402; ..\Source\Debug
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AX58200_MotorControl.bin
  postbuild: genImages.bat
  ILINK.IlinkOutputFile: MotorControl.out
  ILINK.IlinkIcfFile: generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Project/Beckhoff SSC
    ../For_SSC_Tool/Src/: AX58200_FoeAppl.c AX58200_Hw.c AX58200_MotorControl.c AX58200_MotorControlObjects.h bootmode.c coeappl.c ecatappl.c ecatcoe.c ecatfoe.c ecatslv.c foeappl.c mailbox.c objdef.c sdoserv.c
  group Project/CiA402
    ../Source/CiA402/: cia402.c cia402csp.c cia402hm.c cia402pp.c
  group Project/CMSIS
    ./: startup_M480.s
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Project/Debug
    ../Source/Debug/: ax_uart.c clicmd.c console.c printd.c test.c
  group Project/Library
    ../../../Library/StdDriver/src/: clk.c dac.c eadc.c epwm.c fmc.c gpio.c hsusbd.c qei.c retarget.c spi.c spim.c sys.c timer.c uart.c
  group Project/Mchal
    ../Source/Mchal/: McHal_eadc.c McHal_epwm.c McHal_gpio.c McHal_husb.c McHal_misc.c McHal_qei.c McHal_tim.c McHal_vcp_desc.c
  group Project/McInterface
    ../Source/McInterface/: mc.c mc_cfg.h mc_it.c mc_math.c mc_types.h
  group Project/McStack
    ../Source/McStack/: bus_vol_sensor.c curr_fdbk.c das.c flash.c incremental_fdbk.c loop_control.c param_def.h pid.c servo_commu.c stepper_mode.c svpwm.c sw_protection.c temp_sensor.c trajectory_ctrl.c
  group Project/User
    ../Source/: main.c
